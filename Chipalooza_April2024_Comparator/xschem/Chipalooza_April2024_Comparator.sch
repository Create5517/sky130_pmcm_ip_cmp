v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {Hysteresis Select} 1770 -3245 0 0 0.5 0.5 {}
T {Output Stage} 3195 -1330 0 0 0.5 0.5 {}
T {Biasing} 3680 -3235 0 0 0.5 0.5 {}
T {Summing Circuit} 2345 -1560 0 0 0.5 0.5 {}
T {Input Stage} 1495 -1675 0 0 0.5 0.5 {}
N 3225 -1075 3225 -1015 {
lab=SumOutBar}
N 3225 -1195 3225 -1135 {
lab=dvdd}
N 3205 -1195 3225 -1195 {
lab=dvdd}
N 3225 -955 3225 -915 {
lab=dvssi}
N 3195 -915 3225 -915 {
lab=dvssi}
N 3225 -1075 3225 -1015 {
lab=SumOutBar}
N 3135 -1105 3185 -1105 {
lab=SumOut}
N 3135 -985 3185 -985 {
lab=SumOut}
N 3225 -1195 3225 -1135 {
lab=dvdd}
N 3205 -1195 3225 -1195 {
lab=dvdd}
N 3225 -955 3225 -915 {
lab=dvssi}
N 3195 -915 3225 -915 {
lab=dvssi}
N 2165 -2715 2165 -2665 {
lab=avss}
N 2100 -3090 2140 -3090 {
lab=SumOutBar}
N 2250 -3005 2250 -2925 {
lab=#net1}
N 2250 -3030 2250 -3005 {
lab=#net1}
N 2180 -3030 2250 -3030 {
lab=#net1}
N 2180 -3060 2180 -3030 {
lab=#net1}
N 2250 -3030 2305 -3030 {
lab=#net1}
N 2305 -3060 2305 -3030 {
lab=#net1}
N 2305 -3235 2305 -3120 {
lab=N2}
N 2180 -3170 2180 -3120 {
lab=N1}
N 2345 -3090 2410 -3090 {
lab=SumOut}
N 1335 -2685 1335 -2645 {
lab=dvssi}
N 1335 -2645 1475 -2645 {
lab=dvssi}
N 1475 -2685 1475 -2645 {
lab=dvssi}
N 1375 -2715 1435 -2715 {
lab=ibias}
N 1335 -2870 1335 -2745 {
lab=ibias}
N 1395 -2785 1395 -2715 {
lab=ibias}
N 1335 -2785 1395 -2785 {
lab=ibias}
N 1475 -2865 1475 -2745 {
lab=hyst_bias0}
N 1475 -2825 1535 -2825 {
lab=hyst_bias0}
N 1535 -2895 1535 -2825 {
lab=hyst_bias0}
N 1515 -2895 1535 -2895 {
lab=hyst_bias0}
N 1535 -2895 1575 -2895 {
lab=hyst_bias0}
N 1475 -3045 1475 -2925 {
lab=dvdd}
N 1475 -3045 1615 -3045 {
lab=dvdd}
N 1615 -3045 1615 -2925 {
lab=dvdd}
N 1615 -2695 1615 -2655 {
lab=dvssi}
N 1615 -2645 1755 -2645 {
lab=dvssi}
N 1755 -2695 1755 -2655 {
lab=dvssi}
N 1655 -2725 1715 -2725 {
lab=hyst_bias1}
N 1615 -2865 1615 -2755 {
lab=hyst_bias1}
N 1675 -2805 1675 -2725 {
lab=hyst_bias1}
N 1615 -2805 1675 -2805 {
lab=hyst_bias1}
N 1755 -3045 1755 -2755 {
lab=dvdd}
N 1615 -3045 1755 -3045 {
lab=dvdd}
N 3105 -1105 3105 -985 {
lab=SumOut}
N 3105 -985 3135 -985 {
lab=SumOut}
N 3105 -1105 3135 -1105 {
lab=SumOut}
N 2180 -3240 2180 -3170 {
lab=N1}
N 1600 -85 1600 -55 {lab=avss}
N 1600 -150 1600 -145 {
lab=avssi}
N 1600 -190 1600 -150 {
lab=avssi}
N 1530 -190 1600 -190 {
lab=avssi}
N 1600 -115 1630 -115 {
lab=avss}
N 2395 -2715 2395 -2665 {
lab=avss}
N 2320 -2655 2395 -2655 {
lab=avss}
N 2335 -2745 2355 -2745 {
lab=hyst_bias0}
N 2335 -2845 2355 -2845 {
lab=hyst1}
N 2095 -2745 2125 -2745 {
lab=hyst_bias0}
N 2100 -2850 2125 -2850 {
lab=hyst0}
N 2165 -2820 2165 -2775 {
lab=#net2}
N 2395 -2915 2395 -2875 {
lab=#net1}
N 2165 -2915 2165 -2880 {
lab=#net1}
N 2165 -2655 2320 -2655 {
lab=avss}
N 2165 -2665 2165 -2655 {
lab=avss}
N 2395 -2665 2395 -2655 {
lab=avss}
N 2395 -2815 2395 -2775 {
lab=#net3}
N 2165 -2915 2395 -2915 {
lab=#net1}
N 2250 -2925 2250 -2915 {
lab=#net1}
N 1870 -95 1870 -65 {lab=avss}
N 1870 -160 1870 -155 {
lab=dvssi}
N 1870 -200 1870 -160 {
lab=dvssi}
N 1800 -200 1870 -200 {
lab=dvssi}
N 1870 -125 1900 -125 {
lab=avss}
N 1615 -2655 1615 -2645 {
lab=dvssi}
N 1755 -2655 1755 -2645 {
lab=dvssi}
N 1475 -2645 1615 -2645 {
lab=dvssi}
N 3225 -1045 3305 -1045 {
lab=SumOutBar}
N 3385 -1045 3475 -1045 {
lab=vout}
N 3385 -1075 3385 -1015 {
lab=vout}
N 3385 -1075 3385 -1015 {
lab=vout}
N 3325 -1105 3345 -1105 {
lab=SumOutBar}
N 3325 -1105 3325 -985 {
lab=SumOutBar}
N 3325 -985 3345 -985 {
lab=SumOutBar}
N 3305 -1045 3325 -1045 {
lab=SumOutBar}
N 3385 -1165 3385 -1135 {
lab=dvdd}
N 3225 -1165 3385 -1165 {
lab=dvdd}
N 3225 -915 3385 -915 {
lab=dvssi}
N 3385 -955 3385 -915 {
lab=dvssi}
N 2280 -2655 2280 -2565 {
lab=avss}
N 2255 -1360 2255 -1310 {
lab=SourceBias2}
N 2255 -1340 2335 -1340 {
lab=SourceBias2}
N 2335 -1390 2335 -1340 {
lab=SourceBias2}
N 2295 -1390 2335 -1390 {
lab=SourceBias2}
N 2255 -1490 2255 -1420 {
lab=avdd}
N 2255 -1490 2455 -1490 {
lab=avdd}
N 2455 -1490 2455 -1420 {
lab=avdd}
N 2455 -1490 2635 -1490 {
lab=avdd}
N 2655 -1490 2655 -1420 {
lab=avdd}
N 2635 -1490 2655 -1490 {
lab=avdd}
N 2495 -1390 2615 -1390 {
lab=SourceBias2}
N 2525 -1440 2525 -1390 {
lab=SourceBias2}
N 2335 -1440 2525 -1440 {
lab=SourceBias2}
N 2335 -1440 2335 -1390 {
lab=SourceBias2}
N 2455 -1360 2455 -1300 {
lab=N1}
N 2655 -1360 2655 -1270 {
lab=N2}
N 2575 -1320 2655 -1320 {
lab=N2}
N 2575 -1240 2615 -1240 {
lab=Bias1}
N 2495 -1240 2575 -1240 {
lab=Bias1}
N 2455 -1300 2455 -1270 {
lab=N1}
N 2655 -1210 2655 -980 {
lab=SumOut}
N 2455 -1210 2455 -980 {
lab=Sum}
N 2495 -950 2615 -950 {
lab=Bias2}
N 2655 -920 2655 -850 {
lab=P2}
N 2595 -890 2655 -890 {
lab=P2}
N 2595 -910 2595 -890 {
lab=P2}
N 2455 -920 2455 -850 {
lab=P1}
N 2495 -820 2615 -820 {
lab=Sum}
N 2455 -790 2455 -740 {
lab=avss}
N 2455 -740 2655 -740 {
lab=avss}
N 2655 -790 2655 -740 {
lab=avss}
N 2375 -890 2455 -890 {
lab=P1}
N 2375 -900 2375 -890 {
lab=P1}
N 2525 -1040 2525 -820 {
lab=Sum}
N 2455 -1040 2525 -1040 {
lab=Sum}
N 2415 -1310 2455 -1310 {
lab=N1}
N 2545 -1240 2545 -1150 {
lab=Bias1}
N 2545 -1150 2805 -1150 {
lab=Bias1}
N 2555 -1020 2555 -950 {
lab=Bias2}
N 2555 -1020 2795 -1020 {
lab=Bias2}
N 2655 -1090 2725 -1090 {
lab=SumOut}
N 1665 -1365 1665 -1305 {
lab=psource_input}
N 1455 -1365 1665 -1365 {
lab=psource_input}
N 1455 -1365 1455 -1305 {
lab=psource_input}
N 1555 -1395 1555 -1365 {
lab=psource_input}
N 1505 -1555 1555 -1555 {
lab=avdd}
N 1805 -1455 1835 -1455 {
lab=#net4}
N 1555 -1555 1825 -1555 {
lab=avdd}
N 1875 -1555 1875 -1485 {
lab=avdd}
N 1765 -1555 1765 -1485 {
lab=avdd}
N 1815 -1455 1815 -1395 {
lab=#net4}
N 1815 -1395 1875 -1395 {
lab=#net4}
N 1875 -1425 1875 -1395 {
lab=#net4}
N 1765 -1425 1765 -1395 {
lab=psource_input}
N 1615 -1395 1715 -1395 {
lab=psource_input}
N 1615 -1395 1615 -1365 {
lab=psource_input}
N 1665 -1245 1665 -1185 {
lab=P2}
N 1455 -1245 1455 -1185 {
lab=P1}
N 1345 -1405 1555 -1405 {
lab=psource_input}
N 1190 -1360 1190 -1310 {
lab=psource_input}
N 1190 -1410 1190 -1360 {
lab=psource_input}
N 1285 -1405 1345 -1405 {
lab=psource_input}
N 1370 -1275 1415 -1275 {
lab=vinp}
N 1665 -1035 1665 -985 {
lab=N2}
N 1455 -1045 1455 -985 {
lab=N1}
N 1665 -1045 1665 -1035 {
lab=N2}
N 1275 -745 1325 -745 {
lab=nbias_tail}
N 1455 -925 1455 -885 {
lab=SourceBias0}
N 1455 -885 1665 -885 {
lab=SourceBias0}
N 1665 -925 1665 -885 {
lab=SourceBias0}
N 1525 -885 1525 -835 {
lab=SourceBias0}
N 1365 -835 1525 -835 {
lab=SourceBias0}
N 1365 -835 1365 -775 {
lab=SourceBias0}
N 1235 -1405 1285 -1405 {
lab=psource_input}
N 1370 -955 1415 -955 {
lab=vinp}
N 1235 -715 1235 -655 {
lab=avssi}
N 1235 -655 1365 -655 {
lab=avssi}
N 1365 -715 1365 -655 {
lab=avssi}
N 1705 -955 1795 -955 {
lab=vinn}
N 1595 -885 1595 -765 {
lab=SourceBias0}
N 1715 -1395 1765 -1395 {
lab=psource_input}
N 1825 -1555 1875 -1555 {
lab=avdd}
N 1705 -1275 1725 -1275 {
lab=vinn}
N 1725 -1275 1745 -1275 {
lab=vinn}
N 1795 -1275 1795 -955 {
lab=vinn}
N 1745 -1275 1795 -1275 {
lab=vinn}
N 1795 -1125 1825 -1125 {
lab=vinn}
N 1825 -1125 1855 -1125 {
lab=vinn}
N 1305 -825 1305 -745 {
lab=nbias_tail}
N 1235 -825 1305 -825 {
lab=nbias_tail}
N 1595 -815 1875 -815 {
lab=SourceBias0}
N 1875 -815 1935 -815 {
lab=SourceBias0}
N 1935 -825 1935 -815 {
lab=SourceBias0}
N 1935 -1355 1935 -885 {
lab=#net4}
N 1875 -1355 1935 -1355 {
lab=#net4}
N 1875 -1395 1875 -1355 {
lab=#net4}
N 1975 -855 2015 -855 {
lab=Bias5}
N 1345 -1555 1505 -1555 {
lab=avdd}
N 1360 -1580 1360 -1555 {
lab=avdd}
N 1555 -1405 1555 -1395 {
lab=psource_input}
N 1365 -655 1435 -655 {
lab=avssi}
N 1370 -1275 1370 -955 {
lab=vinp}
N 1310 -1125 1340 -1125 {
lab=vinp}
N 1340 -1125 1370 -1125 {
lab=vinp}
N 2970 -2075 3080 -2075 {
lab=hyst_bias0}
N 3120 -2045 3120 -2020 {
lab=avssi}
N 3120 -2105 3140 -2105 {
lab=SourceBias0}
N 3055 -2075 3055 -1990 {
lab=hyst_bias0}
N 3055 -1990 3270 -1990 {
lab=hyst_bias0}
N 3270 -2070 3270 -1990 {
lab=hyst_bias0}
N 3270 -2070 3275 -2070 {
lab=hyst_bias0}
N 3315 -2040 3315 -2015 {
lab=avssi}
N 1505 -1555 1505 -1515 {
lab=avdd}
N 1545 -1485 1590 -1485 {
lab=SourceBias1}
N 1630 -1555 1630 -1515 {
lab=avdd}
N 1630 -1455 1630 -1395 {
lab=psource_input}
N 1505 -1455 1505 -1435 {
lab=SourceBias1}
N 1505 -1435 1565 -1435 {
lab=SourceBias1}
N 1565 -1485 1565 -1435 {
lab=SourceBias1}
N 3315 -2130 3315 -2100 {
lab=SourceBias1}
N 3475 -2035 3475 -2010 {
lab=avssi}
N 3435 -2065 3435 -1990 {
lab=hyst_bias0}
N 3270 -1990 3435 -1990 {
lab=hyst_bias0}
N 3475 -2125 3475 -2095 {
lab=SourceBias2}
N 1190 -1405 1235 -1405 {
lab=psource_input}
N 1190 -1310 1190 -1185 {
lab=psource_input}
N 1190 -1125 1190 -855 {
lab=nbias_tail}
N 1190 -855 1235 -855 {
lab=nbias_tail}
N 1235 -855 1235 -775 {
lab=nbias_tail}
N 920 -1275 955 -1275 {
lab=PBias}
N 920 -1275 920 -1170 {
lab=PBias}
N 925 -1155 1150 -1155 {
lab=PBias}
N 920 -1155 925 -1155 {
lab=PBias}
N 920 -1170 920 -1155 {
lab=PBias}
N 995 -1245 995 -1155 {
lab=PBias}
N 995 -1155 995 -1075 {
lab=PBias}
N 995 -1560 995 -1305 {
lab=avdd}
N 995 -1555 1345 -1555 {
lab=avdd}
N 855 -1415 855 -1085 {
lab=avdd}
N 855 -1415 995 -1415 {
lab=avdd}
N 995 -1075 995 -1000 {
lab=PBias}
N 855 -1085 855 -1050 {
lab=avdd}
N 995 -940 995 -885 {
lab=SourceBias3}
N 925 -885 995 -885 {
lab=SourceBias3}
N 925 -885 925 -880 {
lab=SourceBias3}
N 855 -990 855 -885 {
lab=SourceBias3}
N 855 -885 925 -885 {
lab=SourceBias3}
N 755 -1020 755 -995 {
lab=Bias4}
N 755 -1020 815 -1020 {
lab=Bias4}
N 1060 -970 1060 -945 {
lab=Bias4}
N 1035 -970 1060 -970 {
lab=Bias4}
N 3640 -2035 3640 -2010 {
lab=avssi}
N 3600 -2065 3600 -1990 {
lab=hyst_bias0}
N 3435 -1990 3600 -1990 {
lab=hyst_bias0}
N 3640 -2125 3640 -2095 {
lab=SourceBias3}
N 3805 -2035 3805 -2010 {
lab=avssi}
N 3765 -2065 3765 -1990 {
lab=hyst_bias0}
N 3600 -1990 3765 -1990 {
lab=hyst_bias0}
N 3805 -2125 3805 -2095 {
lab=Bias1}
N 3805 -2035 3805 -2010 {
lab=avssi}
N 3765 -2065 3765 -1990 {
lab=hyst_bias0}
N 3600 -1990 3765 -1990 {
lab=hyst_bias0}
N 3805 -2125 3805 -2095 {
lab=Bias1}
N 3970 -2035 3970 -2010 {
lab=avssi}
N 3930 -2065 3930 -1990 {
lab=hyst_bias0}
N 3765 -1990 3930 -1990 {
lab=hyst_bias0}
N 3970 -2125 3970 -2095 {
lab=SourceBias5}
N 4135 -2035 4135 -2010 {
lab=avssi}
N 4095 -2065 4095 -1990 {
lab=hyst_bias0}
N 3930 -1990 4095 -1990 {
lab=hyst_bias0}
N 4135 -2125 4135 -2095 {
lab=SourceBias6}
N 4300 -2035 4300 -2010 {
lab=avssi}
N 4260 -2065 4260 -1990 {
lab=hyst_bias0}
N 4095 -1990 4260 -1990 {
lab=hyst_bias0}
N 4300 -2125 4300 -2095 {
lab=SourceBias7}
N 4465 -2035 4465 -2010 {
lab=avssi}
N 4425 -2065 4425 -1990 {
lab=hyst_bias0}
N 4260 -1990 4425 -1990 {
lab=hyst_bias0}
N 4465 -2125 4465 -2095 {
lab=Bias5}
N 4465 -2035 4465 -2010 {
lab=avssi}
N 4425 -2065 4425 -1990 {
lab=hyst_bias0}
N 4260 -1990 4425 -1990 {
lab=hyst_bias0}
N 4465 -2125 4465 -2095 {
lab=Bias5}
N 4630 -2035 4630 -2010 {
lab=avssi}
N 4590 -2065 4590 -1990 {
lab=hyst_bias0}
N 4425 -1990 4590 -1990 {
lab=hyst_bias0}
N 4630 -2125 4630 -2095 {
lab=Bias4}
N 4795 -2035 4795 -2010 {
lab=avssi}
N 4755 -2065 4755 -1990 {
lab=hyst_bias0}
N 4590 -1990 4755 -1990 {
lab=hyst_bias0}
N 4795 -2125 4795 -2095 {
lab=SourceBias10}
N 3140 -2155 3140 -2105 {
lab=SourceBias0}
N 3140 -2200 3140 -2155 {
lab=SourceBias0}
N 3125 -2200 3140 -2200 {
lab=SourceBias0}
N 4110 -2690 4110 -2630 {
lab=avss}
N 4110 -2825 4110 -2750 {
lab=M55Source}
N 4260 -2825 4260 -2640 {
lab=avss}
N 4110 -2640 4260 -2640 {
lab=avss}
N 4150 -2720 4180 -2720 {
lab=M55Drain}
N 4180 -2920 4180 -2720 {
lab=M55Drain}
N 4110 -2920 4180 -2920 {
lab=M55Drain}
N 4110 -2920 4110 -2885 {
lab=M55Drain}
N 4260 -2925 4260 -2885 {
lab=Bias2}
N 4150 -2855 4170 -2855 {
lab=Bias2}
N 4170 -2855 4170 -2790 {
lab=Bias2}
N 4170 -2790 4305 -2790 {
lab=Bias2}
N 4305 -2855 4305 -2790 {
lab=Bias2}
N 4305 -2855 4345 -2855 {
lab=Bias2}
N 4300 -2855 4310 -2855 {
lab=Bias2}
N 3440 -3020 3440 -2940 {
lab=#net5}
N 3440 -3120 3440 -3080 {
lab=avdd}
N 3265 -3120 3440 -3120 {
lab=avdd}
N 3265 -3120 3270 -3120 {
lab=avdd}
N 3480 -3050 3515 -3050 {
lab=#net6}
N 3515 -3050 3605 -3050 {
lab=#net6}
N 3440 -3120 3645 -3120 {
lab=avdd}
N 3645 -3120 3645 -3080 {
lab=avdd}
N 3575 -3050 3575 -3000 {
lab=#net6}
N 3575 -3000 3645 -3000 {
lab=#net6}
N 3645 -3020 3645 -3000 {
lab=#net6}
N 3645 -3000 3645 -2930 {
lab=#net6}
N 3575 -2900 3605 -2900 {
lab=SourceBias4}
N 3575 -2900 3575 -2845 {
lab=SourceBias4}
N 3575 -2845 3645 -2845 {
lab=SourceBias4}
N 3645 -2870 3645 -2845 {
lab=SourceBias4}
N 3645 -2845 3645 -2825 {
lab=SourceBias4}
N 3540 -2900 3575 -2900 {
lab=SourceBias4}
N 3500 -2865 3500 -2770 {
lab=avss}
N 3500 -2870 3500 -2860 {
lab=avss}
N 3375 -2930 3500 -2930 {
lab=#net5}
N 3440 -2940 3440 -2930 {
lab=#net5}
N 3375 -2870 3375 -2850 {
lab=Bias1}
N 3310 -2900 3335 -2900 {
lab=Bias1}
N 3310 -2900 3310 -2860 {
lab=Bias1}
N 3310 -2860 3375 -2860 {
lab=Bias1}
N 3235 -2900 3310 -2900 {
lab=Bias1}
N 4325 -2905 4325 -2855 {
lab=Bias2}
N 4260 -2905 4325 -2905 {
lab=Bias2}
N 4665 -3015 4665 -2935 {
lab=#net7}
N 4665 -3115 4665 -3075 {
lab=avdd}
N 4490 -3115 4665 -3115 {
lab=avdd}
N 4490 -3115 4495 -3115 {
lab=avdd}
N 4705 -3045 4740 -3045 {
lab=#net8}
N 4740 -3045 4830 -3045 {
lab=#net8}
N 4665 -3115 4870 -3115 {
lab=avdd}
N 4870 -3115 4870 -3075 {
lab=avdd}
N 4800 -3045 4800 -2995 {
lab=#net8}
N 4800 -2995 4870 -2995 {
lab=#net8}
N 4870 -3015 4870 -2995 {
lab=#net8}
N 4870 -2995 4870 -2925 {
lab=#net8}
N 4800 -2895 4830 -2895 {
lab=SourceBias10}
N 4800 -2895 4800 -2840 {
lab=SourceBias10}
N 4800 -2840 4870 -2840 {
lab=SourceBias10}
N 4870 -2865 4870 -2840 {
lab=SourceBias10}
N 4870 -2840 4870 -2820 {
lab=SourceBias10}
N 4765 -2895 4800 -2895 {
lab=SourceBias10}
N 4725 -2860 4725 -2765 {
lab=avss}
N 4725 -2865 4725 -2855 {
lab=avss}
N 4600 -2925 4725 -2925 {
lab=#net7}
N 4665 -2935 4665 -2925 {
lab=#net7}
N 4600 -2865 4600 -2845 {
lab=Bias4}
N 4535 -2895 4560 -2895 {
lab=Bias4}
N 4535 -2895 4535 -2855 {
lab=Bias4}
N 4535 -2855 4600 -2855 {
lab=Bias4}
N 4460 -2895 4535 -2895 {
lab=Bias4}
N 3725 -2550 3725 -2470 {
lab=#net9}
N 3725 -2650 3725 -2610 {
lab=avdd}
N 3550 -2650 3725 -2650 {
lab=avdd}
N 3550 -2650 3555 -2650 {
lab=avdd}
N 3765 -2580 3800 -2580 {
lab=#net10}
N 3800 -2580 3890 -2580 {
lab=#net10}
N 3725 -2650 3930 -2650 {
lab=avdd}
N 3930 -2650 3930 -2610 {
lab=avdd}
N 3860 -2580 3860 -2530 {
lab=#net10}
N 3860 -2530 3930 -2530 {
lab=#net10}
N 3930 -2550 3930 -2530 {
lab=#net10}
N 3930 -2530 3930 -2460 {
lab=#net10}
N 3860 -2430 3890 -2430 {
lab=SourceBias7}
N 3860 -2430 3860 -2375 {
lab=SourceBias7}
N 3860 -2375 3930 -2375 {
lab=SourceBias7}
N 3930 -2400 3930 -2375 {
lab=SourceBias7}
N 3930 -2375 3930 -2355 {
lab=SourceBias7}
N 3825 -2430 3860 -2430 {
lab=SourceBias7}
N 3785 -2395 3785 -2300 {
lab=avss}
N 3785 -2400 3785 -2390 {
lab=avss}
N 3660 -2460 3785 -2460 {
lab=#net9}
N 3725 -2470 3725 -2460 {
lab=#net9}
N 3660 -2400 3660 -2380 {
lab=Bias5}
N 3595 -2430 3620 -2430 {
lab=Bias5}
N 3595 -2430 3595 -2390 {
lab=Bias5}
N 3595 -2390 3660 -2390 {
lab=Bias5}
N 3520 -2430 3595 -2430 {
lab=Bias5}
N 3985 -3080 3985 -3040 {
lab=avdd}
N 4025 -3010 4070 -3010 {
lab=SourceBias5}
N 4110 -3080 4110 -3040 {
lab=avdd}
N 4110 -2980 4110 -2920 {
lab=M55Drain}
N 3985 -2980 3985 -2960 {
lab=SourceBias5}
N 3985 -2960 4045 -2960 {
lab=SourceBias5}
N 4045 -3010 4045 -2960 {
lab=SourceBias5}
N 4385 -3080 4385 -3040 {
lab=avdd}
N 4300 -3010 4345 -3010 {
lab=SourceBias6}
N 4260 -3080 4260 -3040 {
lab=avdd}
N 4260 -2980 4260 -2920 {
lab=Bias2}
N 4385 -2980 4385 -2960 {
lab=SourceBias6}
N 4325 -2960 4385 -2960 {
lab=SourceBias6}
N 4325 -3010 4325 -2960 {
lab=SourceBias6}
N 3915 -3115 4490 -3115 {
lab=avdd}
N 3985 -3115 3985 -3080 {
lab=avdd}
N 4110 -3115 4110 -3080 {
lab=avdd}
N 4260 -3115 4260 -3080 {
lab=avdd}
N 4385 -3115 4385 -3080 {
lab=avdd}
C {devices/ipin.sym} 110 -710 0 0 {name=p48 lab=vinp
}
C {devices/ipin.sym} 110 -680 0 0 {name=p4 lab=vinn
}
C {devices/ipin.sym} 110 -820 0 0 {name=p19 lab=hyst0
}
C {devices/ipin.sym} 110 -790 0 0 {name=p20 lab=hyst1
}
C {devices/ipin.sym} 225 -865 0 0 {name=p37 lab=avdd
}
C {devices/ipin.sym} 230 -795 0 0 {name=p38 lab=avss
}
C {devices/ipin.sym} 240 -755 0 0 {name=p39 lab=dvdd
}
C {devices/ipin.sym} 240 -725 0 0 {name=p40 lab=dvss
}
C {devices/opin.sym} 195 -675 0 0 { name=p116 lab=vout}
C {devices/ipin.sym} 115 -650 0 0 {name=p42 lab=ena
}
C {devices/ipin.sym} 105 -915 0 0 {name=p27 lab=ibias
}
C {sky130_fd_pr/pfet_01v8.sym} 3205 -1105 0 0 {name=M29
L=1
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 3475 -1045 0 1 {name=l39 lab=vout
}
C {devices/lab_pin.sym} 3205 -1195 0 0 {name=l40 lab=dvdd
}
C {sky130_fd_pr/nfet_01v8.sym} 3205 -985 0 0 {name=M30
L=1
W=2
nf=1 
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 3225 -985 0 1 {name=l43 lab=dvss
}
C {devices/lab_pin.sym} 3225 -1105 0 1 {name=l44 lab=dvdd
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2145 -2745 0 0 {name=M25
L=1
W=3
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 2165 -2745 0 1 {name=p41 lab=avss
}
C {sky130_fd_pr/nfet_01v8.sym} 1455 -2715 0 0 {name=M26
L=1
W=3
mult=2 nf=1
model=nfet_01v8
spiceprefix=X}
C {sky130_fd_pr/nfet_01v8.sym} 1355 -2715 0 1 {name=M27
L=1
W=3
mult=2 nf=1
model=nfet_01v8
spiceprefix=X}
C {devices/lab_pin.sym} 1335 -2645 0 0 {name=p34 sig_type=std_logic lab=dvssi

}
C {devices/lab_pin.sym} 1335 -2870 0 0 {name=p53 sig_type=std_logic lab=ibias


}
C {sky130_fd_pr/pfet_01v8.sym} 1595 -2895 0 0 {name=M34
L=1
W=3
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1495 -2895 0 1 {name=M35
L=1
W=3
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 1475 -2715 0 1 {name=p55 sig_type=std_logic lab=dvss

}
C {devices/lab_pin.sym} 1335 -2715 0 0 {name=p56 sig_type=std_logic lab=dvss

}
C {devices/lab_pin.sym} 1475 -3045 0 0 {name=p57 sig_type=std_logic lab=dvdd

}
C {devices/lab_pin.sym} 1475 -2800 0 1 {name=p59 sig_type=std_logic lab=hyst_bias0


}
C {sky130_fd_pr/nfet_01v8.sym} 1735 -2725 0 0 {name=M36
L=1
W=3
mult=2 nf=1
model=nfet_01v8
spiceprefix=X}
C {sky130_fd_pr/nfet_01v8.sym} 1635 -2725 0 1 {name=M37
L=1
W=3
mult=2 nf=1
model=nfet_01v8
spiceprefix=X}
C {devices/lab_pin.sym} 1755 -2725 0 1 {name=p60 sig_type=std_logic lab=dvss

}
C {devices/lab_pin.sym} 1615 -2725 0 0 {name=p61 sig_type=std_logic lab=dvss

}
C {devices/lab_pin.sym} 1675 -2785 0 1 {name=p62 sig_type=std_logic lab=hyst_bias1


}
C {devices/lab_pin.sym} 1475 -2895 0 0 {name=p24 sig_type=std_logic lab=dvdd

}
C {devices/lab_pin.sym} 1615 -2895 0 1 {name=p63 sig_type=std_logic lab=dvdd

}
C {devices/lab_pin.sym} 3105 -1055 2 1 {name=l9 lab=SumOut
}
C {devices/lab_pin.sym} 3225 -1045 2 1 {name=l37 lab=SumOutBar
}
C {devices/lab_pin.sym} 2410 -3090 2 0 {name=l20 lab=SumOut
}
C {devices/lab_pin.sym} 2100 -3090 2 1 {name=l32 lab=SumOutBar
}
C {devices/lab_pin.sym} 2180 -3240 0 0 {name=l15 lab=N1}
C {devices/lab_pin.sym} 2305 -3235 0 0 {name=l31 lab=N2}
C {devices/lab_pin.sym} 3195 -915 0 0 {name=l41 lab=dvssi
}
C {devices/lab_pin.sym} 1560 -115 0 0 {name=l48 lab=ena}
C {devices/lab_pin.sym} 1600 -75 0 0 {name=p12 lab=avss
}
C {devices/parax_cap.sym} 1600 -45 0 0 {name=C1  value=2p}
C {devices/lab_pin.sym} 1630 -115 0 1 {name=p13 sig_type=std_logic lab=avss


}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1580 -115 0 0 {name=M38
L=1
W=16
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2375 -2745 0 0 {name=M39
L=1
W=8
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 2395 -2745 0 1 {name=p44 lab=avss
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2145 -2850 0 0 {name=M40
L=1
W=3
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2375 -2845 0 0 {name=M41
L=1
W=8
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 2100 -2850 0 0 {name=p46 sig_type=std_logic lab=hyst0

}
C {devices/lab_pin.sym} 2335 -2845 0 0 {name=p51 sig_type=std_logic lab=hyst1

}
C {devices/lab_pin.sym} 2095 -2745 0 0 {name=p43 sig_type=std_logic lab=hyst_bias0


}
C {devices/lab_pin.sym} 2335 -2745 0 0 {name=p45 sig_type=std_logic lab=hyst_bias0


}
C {devices/lab_pin.sym} 2165 -2850 0 1 {name=p29 lab=avss
}
C {devices/lab_pin.sym} 2395 -2845 0 1 {name=p52 lab=avss
}
C {devices/lab_pin.sym} 1830 -125 0 0 {name=l6 lab=ena}
C {devices/lab_pin.sym} 1870 -85 0 0 {name=p18 lab=avss
}
C {devices/parax_cap.sym} 1870 -55 0 0 {name=C2  value=2p}
C {devices/lab_pin.sym} 1900 -125 0 1 {name=p21 sig_type=std_logic lab=avss


}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1850 -125 0 0 {name=M13
L=1
W=16
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 1800 -200 0 0 {name=l47 lab=dvssi}
C {sky130_fd_pr/pfet_01v8.sym} 3365 -1105 0 0 {name=M16
L=1
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3365 -985 0 0 {name=M18
L=1
W=2
nf=1 
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 3385 -985 0 1 {name=l42 lab=dvss
}
C {devices/lab_pin.sym} 3385 -1105 0 1 {name=l45 lab=dvdd
}
C {devices/lab_pin.sym} 2280 -2565 0 0 {name=p23 lab=avss
}
C {sky130_fd_pr/pfet_01v8.sym} 2155 -3090 0 0 {name=M19
L=1
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2325 -3090 0 1 {name=M24
L=1
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 2175 -3090 0 1 {name=p25 sig_type=std_logic lab=dvdd

}
C {devices/lab_pin.sym} 2305 -3090 0 0 {name=p26 sig_type=std_logic lab=dvdd

}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 2275 -1390 0 1 {name=M4
L=1
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 2475 -1390 0 1 {name=M5
L=1
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 2635 -1390 0 0 {name=M6
L=1
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 2635 -1240 0 0 {name=M7
L=1
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 2475 -1240 0 1 {name=M8
L=1
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2635 -950 0 0 {name=M9
L=1
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 2575 -1320 0 0 {name=l1 lab=N2}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2475 -950 0 1 {name=M10
L=1
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2635 -820 0 0 {name=M11
L=1
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 2595 -910 0 0 {name=l2 lab=P2
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2475 -820 0 1 {name=M12
L=1
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 2375 -900 0 0 {name=l3 lab=P1
}
C {devices/lab_pin.sym} 2415 -1310 0 0 {name=l4 lab=N1}
C {devices/lab_pin.sym} 2805 -1150 0 1 {name=l5 lab=Bias1
}
C {devices/lab_pin.sym} 2255 -1390 0 0 {name=l24 lab=avdd
}
C {devices/lab_pin.sym} 2455 -1390 0 0 {name=l25 lab=avdd
}
C {devices/lab_pin.sym} 2655 -1390 0 1 {name=l26 lab=avdd
}
C {devices/lab_pin.sym} 2655 -1240 0 1 {name=l27 lab=avdd
}
C {devices/lab_pin.sym} 2455 -1240 0 0 {name=l28 lab=avdd
}
C {devices/lab_pin.sym} 2255 -1490 0 0 {name=l29 lab=avdd
}
C {devices/lab_pin.sym} 2455 -950 0 0 {name=p8 lab=avss
}
C {devices/lab_pin.sym} 2655 -950 0 1 {name=p9 lab=avss
}
C {devices/lab_pin.sym} 2655 -820 0 1 {name=p10 lab=avss
}
C {devices/lab_pin.sym} 2455 -820 0 0 {name=p11 lab=avss
}
C {devices/lab_pin.sym} 2455 -740 0 0 {name=p1 lab=avss
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 1685 -1275 0 1 {name=M2
L=1
W=4
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 1435 -1275 0 0 {name=M3
L=1
W=4
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 1785 -1455 0 1 {name=M14
L=1
W=12
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 1855 -1455 0 0 {name=M15
L=1
W=8
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 1665 -1185 0 1 {name=l7 lab=P2}
C {devices/lab_pin.sym} 1455 -1185 0 0 {name=l8 lab=P1}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 1170 -1155 0 0 {name=M17
L=1
W=8
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1435 -955 0 0 {name=M20
L=4
W=16
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1685 -955 0 1 {name=M21
L=4
W=16
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 1665 -1045 0 1 {name=l10 lab=N2}
C {devices/lab_pin.sym} 1455 -1045 0 0 {name=l11 lab=N1}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1345 -745 0 0 {name=M22
L=1
W=12
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1255 -745 0 1 {name=M23
L=1
W=12
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 1855 -1125 0 1 {name=l13 lab=vinn
}
C {devices/lab_pin.sym} 1360 -1580 0 0 {name=l14 lab=avdd
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1955 -855 0 1 {name=M28
L=1
W=4
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 2015 -855 0 1 {name=l16 lab=Bias5
}
C {devices/lab_pin.sym} 1665 -1275 0 0 {name=l18 lab=avdd
}
C {devices/lab_pin.sym} 1455 -1275 0 1 {name=l19 lab=avdd
}
C {devices/lab_pin.sym} 1190 -1155 0 1 {name=l21 lab=avdd
}
C {devices/lab_pin.sym} 1365 -745 0 1 {name=p3 sig_type=std_logic lab=avss


}
C {devices/lab_pin.sym} 1235 -745 0 0 {name=p5 sig_type=std_logic lab=avss


}
C {devices/lab_pin.sym} 1665 -955 0 0 {name=p6 sig_type=std_logic lab=avss


}
C {devices/lab_pin.sym} 1455 -955 0 1 {name=p7 sig_type=std_logic lab=avss


}
C {devices/lab_pin.sym} 1935 -855 0 0 {name=p22 sig_type=std_logic lab=avss


}
C {devices/lab_pin.sym} 1765 -1455 0 0 {name=l22 lab=avdd
}
C {devices/lab_pin.sym} 1555 -1385 0 0 {name=l34 lab=psource_input
}
C {devices/lab_pin.sym} 1310 -1125 0 0 {name=l12 lab=vinp
}
C {devices/lab_pin.sym} 1235 -855 0 1 {name=l33 lab=nbias_tail
}
C {devices/lab_pin.sym} 2725 -1090 2 0 {name=l30 lab=SumOut
}
C {devices/lab_pin.sym} 2455 -1110 2 0 {name=l36 lab=Sum
}
C {devices/lab_pin.sym} 2795 -1020 0 1 {name=p28 sig_type=std_logic lab=Bias2


}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 3100 -2075 0 0 {name=M31
L=1
W=16
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 3120 -2075 0 1 {name=p64 sig_type=std_logic lab=avss


}
C {devices/lab_pin.sym} 3120 -2020 0 1 {name=p68 sig_type=std_logic lab=avssi


}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 3295 -2070 0 0 {name=M45
L=1
W=16
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 3315 -2015 0 1 {name=p31 sig_type=std_logic lab=avssi


}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 1525 -1485 0 1 {name=M46
L=1
W=12
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 1610 -1485 0 0 {name=M47
L=1
W=12
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 1505 -1435 0 0 {name=l53 lab=SourceBias1
}
C {devices/lab_pin.sym} 3315 -2130 0 0 {name=l54 lab=SourceBias1
}
C {devices/lab_pin.sym} 3315 -2070 0 1 {name=p69 sig_type=std_logic lab=avss


}
C {devices/lab_pin.sym} 1630 -1485 0 1 {name=l55 lab=avdd
}
C {devices/lab_pin.sym} 1875 -1455 0 1 {name=l57 lab=avdd
}
C {devices/lab_pin.sym} 1505 -1485 2 1 {name=l58 lab=avdd
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 3455 -2065 0 0 {name=M48
L=1
W=16
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 3475 -2010 0 1 {name=p70 sig_type=std_logic lab=avssi


}
C {devices/lab_pin.sym} 3475 -2125 0 0 {name=l23 lab=SourceBias2}
C {devices/lab_pin.sym} 2255 -1310 0 0 {name=l59 lab=SourceBias2}
C {devices/lab_pin.sym} 3475 -2065 0 1 {name=p32 sig_type=std_logic lab=avss


}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 975 -1275 0 0 {name=M63
L=5
W=3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 995 -1275 0 1 {name=l78 lab=avdd
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 835 -1020 0 0 {name=M62
L=1
W=4
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 855 -1020 0 1 {name=p79 sig_type=std_logic lab=avss


}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1015 -970 0 1 {name=M64
L=1
W=4
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 995 -970 0 0 {name=p80 sig_type=std_logic lab=avss


}
C {devices/lab_pin.sym} 1060 -945 0 1 {name=p83 lab=Bias4
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 3620 -2065 0 0 {name=M65
L=1
W=16
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 3640 -2010 0 1 {name=p84 sig_type=std_logic lab=avssi


}
C {devices/lab_pin.sym} 3640 -2125 0 0 {name=l17 lab=SourceBias3}
C {devices/lab_pin.sym} 3640 -2065 0 1 {name=p85 sig_type=std_logic lab=avss


}
C {devices/lab_pin.sym} 855 -885 0 0 {name=l77 lab=SourceBias3}
C {devices/lab_pin.sym} 755 -995 2 1 {name=p81 lab=Bias4
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 3785 -2065 0 0 {name=M76
L=1
W=16
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 3805 -2125 0 0 {name=l93 lab=Bias1}
C {devices/lab_pin.sym} 3805 -2065 0 1 {name=p35 sig_type=std_logic lab=avss


}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 3950 -2065 0 0 {name=M77
L=1
W=16
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 3970 -2010 0 1 {name=p90 sig_type=std_logic lab=avssi


}
C {devices/lab_pin.sym} 3970 -2125 0 0 {name=l94 lab=SourceBias5}
C {devices/lab_pin.sym} 3970 -2065 0 1 {name=p91 sig_type=std_logic lab=avss


}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 4115 -2065 0 0 {name=M78
L=1
W=16
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 4135 -2010 0 1 {name=p92 sig_type=std_logic lab=avssi


}
C {devices/lab_pin.sym} 4135 -2125 0 0 {name=l95 lab=SourceBias6}
C {devices/lab_pin.sym} 4135 -2065 0 1 {name=p93 sig_type=std_logic lab=avss


}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 4280 -2065 0 0 {name=M79
L=1
W=16
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 4300 -2010 0 1 {name=p94 sig_type=std_logic lab=avssi


}
C {devices/lab_pin.sym} 4300 -2125 0 0 {name=l96 lab=SourceBias7}
C {devices/lab_pin.sym} 4300 -2065 0 1 {name=p95 sig_type=std_logic lab=avss


}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 4445 -2065 0 0 {name=M81
L=1
W=16
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 4465 -2010 0 1 {name=p98 sig_type=std_logic lab=avssi


}
C {devices/lab_pin.sym} 4465 -2125 0 0 {name=l98 lab=Bias5}
C {devices/lab_pin.sym} 4465 -2065 0 1 {name=p99 sig_type=std_logic lab=avss


}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 4610 -2065 0 0 {name=M82
L=1
W=16
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 4630 -2010 0 1 {name=p100 sig_type=std_logic lab=avssi


}
C {devices/lab_pin.sym} 4630 -2125 0 0 {name=l99 lab=Bias4}
C {devices/lab_pin.sym} 4630 -2065 0 1 {name=p101 sig_type=std_logic lab=avss


}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 4775 -2065 0 0 {name=M83
L=1
W=16
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 4795 -2010 0 1 {name=p102 sig_type=std_logic lab=avssi
}
C {devices/lab_pin.sym} 4795 -2125 0 0 {name=l100 lab=SourceBias10}
C {devices/lab_pin.sym} 4795 -2065 0 1 {name=p103 sig_type=std_logic lab=avss


}
C {devices/lab_pin.sym} 1530 -190 0 0 {name=l46 lab=avssi}
C {devices/lab_pin.sym} 1435 -655 0 1 {name=l49 lab=avssi}
C {devices/lab_pin.sym} 3125 -2200 0 0 {name=l50 lab=SourceBias0
}
C {devices/lab_pin.sym} 1595 -770 0 1 {name=l51 lab=SourceBias0
}
C {devices/lab_pin.sym} 4110 -2630 0 1 {name=p74 sig_type=std_logic lab=avss


}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 4130 -2720 0 1 {name=M54
L=1.5
W=6
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 4130 -2855 0 1 {name=M55
L=1
W=9
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 4280 -2855 0 1 {name=M56
L=2
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 4110 -2855 2 1 {name=p75 sig_type=std_logic lab=avss


}
C {devices/lab_pin.sym} 4260 -2855 2 1 {name=p76 sig_type=std_logic lab=avss


}
C {devices/lab_pin.sym} 4110 -2720 2 1 {name=p77 sig_type=std_logic lab=avss


}
C {devices/lab_pin.sym} 4345 -2855 2 0 {name=l67 lab=Bias2
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 3460 -3050 0 1 {name=M51
L=2
W=20
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 3440 -3050 0 0 {name=l62 lab=avdd
}
C {devices/lab_pin.sym} 3265 -3120 0 0 {name=l63 lab=avdd
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 3625 -3050 0 0 {name=M49
L=2
W=10
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 3645 -3050 2 0 {name=l60 lab=avdd
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 3625 -2900 0 0 {name=M50
L=1
W=10
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 3645 -2900 2 0 {name=l61 lab=avdd
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 3520 -2900 0 1 {name=M52
L=1
W=1
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 3500 -2770 0 1 {name=p72 sig_type=std_logic lab=avss


}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 3355 -2900 0 0 {name=M53
L=1
W=10
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 3235 -2900 0 0 {name=l64 lab=Bias1
}
C {devices/lab_pin.sym} 3375 -2900 2 0 {name=l68 lab=avdd
}
C {devices/lab_pin.sym} 3500 -2900 0 0 {name=l69 lab=avdd
}
C {devices/lab_pin.sym} 4110 -2905 2 1 {name=p14 sig_type=std_logic lab=M55Drain


}
C {devices/lab_pin.sym} 4110 -2785 2 1 {name=p15 sig_type=std_logic lab=M55Source



}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 4685 -3045 0 1 {name=M57
L=2
W=20
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 4665 -3045 0 0 {name=l70 lab=avdd
}
C {devices/lab_pin.sym} 3915 -3115 0 0 {name=l71 lab=avdd
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 4850 -3045 0 0 {name=M58
L=2
W=10
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 4870 -3045 2 0 {name=l72 lab=avdd
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 4850 -2895 0 0 {name=M59
L=1
W=10
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 4870 -2895 2 0 {name=l73 lab=avdd
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 4745 -2895 0 1 {name=M60
L=1
W=1
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 4725 -2765 0 1 {name=p17 sig_type=std_logic lab=avss


}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 4580 -2895 0 0 {name=M61
L=1
W=5
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 4460 -2895 0 0 {name=l74 lab=Bias4
}
C {devices/lab_pin.sym} 4600 -2895 2 0 {name=l75 lab=avdd
}
C {devices/lab_pin.sym} 4725 -2895 0 0 {name=l76 lab=avdd
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 3745 -2580 0 1 {name=M66
L=2
W=20
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 3725 -2580 0 0 {name=l79 lab=avdd
}
C {devices/lab_pin.sym} 3550 -2650 0 0 {name=l80 lab=avdd
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 3910 -2580 0 0 {name=M67
L=2
W=20
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 3930 -2580 2 0 {name=l81 lab=avdd
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 3910 -2430 0 0 {name=M68
L=1
W=10
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 3930 -2430 2 0 {name=l82 lab=avdd
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 3805 -2430 0 1 {name=M69
L=1
W=1
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 3785 -2300 0 1 {name=p86 sig_type=std_logic lab=avss


}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 3640 -2430 0 0 {name=M70
L=1
W=5
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 3520 -2430 0 0 {name=l83 lab=Bias5
}
C {devices/lab_pin.sym} 3660 -2430 2 0 {name=l84 lab=avdd
}
C {devices/lab_pin.sym} 3785 -2430 0 0 {name=l85 lab=avdd
}
C {devices/lab_pin.sym} 3645 -2825 0 0 {name=l88 lab=SourceBias4}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 4005 -3010 0 1 {name=M72
L=1
W=12
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 4090 -3010 0 0 {name=M73
L=1
W=12
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 3985 -2960 0 0 {name=l89 lab=SourceBias5
}
C {devices/lab_pin.sym} 4110 -3010 0 1 {name=l90 lab=avdd
}
C {devices/lab_pin.sym} 3985 -3010 2 1 {name=l91 lab=avdd
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 4365 -3010 0 0 {name=M74
L=1
W=12
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 4280 -3010 0 1 {name=M75
L=1
W=12
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 4385 -2960 0 1 {name=l65 lab=SourceBias6
}
C {devices/lab_pin.sym} 4260 -3010 0 0 {name=l66 lab=avdd
}
C {devices/lab_pin.sym} 4385 -3010 2 0 {name=l92 lab=avdd
}
C {devices/lab_pin.sym} 3930 -2355 2 1 {name=l102 lab=SourceBias7
}
C {devices/lab_pin.sym} 4870 -2820 0 0 {name=l104 lab=SourceBias10
}
C {devices/lab_pin.sym} 3805 -2010 0 1 {name=p33 sig_type=std_logic lab=avssi


}
C {devices/lab_pin.sym} 920 -1185 0 1 {name=p49 lab=PBias
}
C {devices/lab_pin.sym} 2970 -2075 0 0 {name=p2 sig_type=std_logic lab=hyst_bias0


}
